# Keil uVision project STM32.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1293  --gnu -Dlittle_endian
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\User\APP;..\User\BSP;..\User\uC-CPU;..\User\uC-CPU\ARM-Cortex-M3\RealView;..\User\uC-LIB;..\User\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\User\uCOS-III\Source;..\User\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\User\BSP\Exit;..\User\BSP\NVIC;..\User\APP\Control;..\User\BSP\Systick;..\MPU6050DMP;..\User\BSP\IO;..\User\BSP\TIM;..\MPU6050DMP\filter;..\Probe;..\FATFS;..\User\BSP\Sdcard;..\User\BSP\PCM1770;..\User\APP\WavPlay;..\User\BSP\usart;..\User\APP\GPRS;..\User\BSP\FLASH;..\User\BSP\IWDG;..\User\APP\Update;..\User\BSP\SPI;..\User\APP\Drawing;..\User\BSP\ADC;..\User\BSP\X9313W;..\User\APP\SELECT;..\User\APP\IMG;..\User\APP\Game;..\User\APP\GameAPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Doc
    ../Doc/: readme.txt
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWlib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_adc.c
  group USER
    ../User/: stm32f10x_it.c stm32f10x_conf.h
  group APP
    ../User/APP/: app.c os_app_hooks.c debug.c
    ../User/APP/Control/: Control.c
    ../User/APP/WavPlay/: WavPlay.c
    ../User/APP/Update/: update.c
    ../User/APP/Drawing/: Drawing.c
    ../User/APP/GPRS/: GPRS.c
    ../User/APP/IMG/: img.c
  group BSP
    ../User/BSP/: bsp.c
    ../User/BSP/Systick/: Systick.C
    ../User/BSP/Exit/: Exti.c
    ../User/BSP/NVIC/: NVIC.C
    ../User/BSP/IO/: in_output.c
    ../User/BSP/TIM/: TIM.C
    ../User/BSP/Sdcard/: sdio_sdcard.c
    ../User/BSP/PCM1770/: IIS.c PCM1770.c
    ../User/BSP/usart/: usart.c
    ../User/BSP/FLASH/: flash.c
    ../User/BSP/IWDG/: iwdg.c
    ../User/BSP/SPI/: SPI.c
    ../User/BSP/ADC/: ADC.c
    ../User/BSP/X9313W/: x9313w.c
  group uC/CPU
    ../User/uC-CPU/: cpu_core.c
    ../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
  group uC/LIB
    ../User/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../User/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../User/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../User/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group MPU6050DMP
    ../MPU6050DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c IOI2C.c MPU6050.c
    ../MPU6050DMP/filter/: filter.c
  group FATFS
    ../FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group Game
    ../User/APP/Game/: game_ball.c shapeBalls.c gold.c tank_war.c car_run.c
  group GameAPI
    ../User/APP/GameAPI/: gameapi.c gui.c shapes.c gplatform.c gameAPIadv.c randADC.c
